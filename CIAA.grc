options:
  parameters:
    author: nix
    generate_options: qt_gui
    id: CIAA
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f:\Proyectos\sist_adq_dbf\gnuradio\sink_UDP
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f:\Proyectos\sist_adq_dbf\gnuradio\sink_channel0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_1_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_6
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_7
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_8
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import struct
      import numpy as np


      NUM_CHANNELS = 16
      SAMPLES_PER_PACKET = 21
      PACKET_HEADER_SIZE = 88  # Header del paquete CIAA (AcqPack_Header_t)
      EXPECTED_PACKET_SIZE = 1432  # 88 header + 1344 payload
      MAX_PACKETS_PER_WORK = 10  # Procesar hasta 10 paquetes por llamada

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='CIAA UDP Unpacker',
                  in_sig=[np.uint8],
                  out_sig=[np.float32]*NUM_CHANNELS
              )
              self.buffer = bytearray()
              self.packet_count = 0
              self.error_count = 0

          def work(self, input_items, output_items):
              # Acumula los bytes recibidos
              in_len = len(input_items[0])
              self.buffer.extend(input_items[0].tobytes())
              
              n_produced = 0
              max_output = len(output_items[0])
              packets_processed = 0

              # Procesar múltiples paquetes (hasta MAX_PACKETS_PER_WORK)
              while (len(self.buffer) >= EXPECTED_PACKET_SIZE and 
                     n_produced + SAMPLES_PER_PACKET <= max_output and
                     packets_processed < MAX_PACKETS_PER_WORK):
                  
                  data = self.buffer[:EXPECTED_PACKET_SIZE]
                  self.buffer = self.buffer[EXPECTED_PACKET_SIZE:]
                  self.packet_count += 1
                  packets_processed += 1

                  try:
                      # Saltar header de 88 bytes
                      payload_start = PACKET_HEADER_SIZE
                      
                      # Extraer samples por canal
                      for row in range(SAMPLES_PER_PACKET):
                          for ch in range(NUM_CHANNELS):
                              # Offset: row * 16 canales * 4 bytes + canal * 4 bytes
                              offset = payload_start + (row * NUM_CHANNELS * 4) + (ch * 4)
                              
                              if offset + 4 <= len(data):
                                  word32 = struct.unpack('<I', data[offset:offset+4])[0]
                                  value16 = word32 & 0xFFFF
                                  signed_val = struct.unpack('<h', struct.pack('<H', value16))[0]
                                  output_items[ch][n_produced] = float(signed_val)
                          
                          n_produced += 1
                      
                  except Exception as e:
                      self.error_count += 1
                      if self.error_count <= 10:
                          print(f"ERROR paquete #{self.packet_count}: {e}")

              # Debug periódico
              if self.packet_count % 100 == 0 and self.packet_count > 0:
                  print(f"Paquete {self.packet_count}: {packets_processed} procesados, buffer: {len(self.buffer)} bytes, errores: {self.error_count}")

              # Consumir todos los bytes de entrada
              self.consume_each(in_len)
              return n_produced
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '9999'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '4096'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [epy_block_0, '0', blocks_file_sink_1, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '1', blocks_null_sink_0, '0']
- [epy_block_0, '10', blocks_null_sink_0_2_1_2, '0']
- [epy_block_0, '11', blocks_null_sink_0_8, '0']
- [epy_block_0, '12', blocks_null_sink_0_3, '0']
- [epy_block_0, '13', blocks_null_sink_0_2, '0']
- [epy_block_0, '14', blocks_null_sink_0_2_0, '0']
- [epy_block_0, '15', blocks_null_sink_0_2_1, '0']
- [epy_block_0, '2', blocks_null_sink_0_0, '0']
- [epy_block_0, '3', blocks_null_sink_0_1, '0']
- [epy_block_0, '4', blocks_null_sink_0_4, '0']
- [epy_block_0, '5', blocks_null_sink_0_5, '0']
- [epy_block_0, '6', blocks_null_sink_0_2_1_0, '0']
- [epy_block_0, '7', blocks_null_sink_0_6, '0']
- [epy_block_0, '8', blocks_null_sink_0_2_1_1, '0']
- [epy_block_0, '9', blocks_null_sink_0_7, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_stream_x_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
