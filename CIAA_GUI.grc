options:
  parameters:
    author: CIAA Project
    description: Interfaz gráfica para control CIAA-ACC con visualización de flujo de datos
    generate_options: qt_gui
    id: CIAA_GUI
    output_language: python
    title: CIAA Control GUI
  states: {}

blocks:
- name: data_source_mux
  id: variable_qtgui_chooser
  parameters:
    comment: DATA_Source_Mux_Control
    gui_hint: 1,0,1,2
    label: Data Source
    label0: DATOS_ADC
    label1: OSC_LOC
    label2: CONTADOR
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: debug_mode
  id: variable_qtgui_chooser
  parameters:
    comment: DEBUG_Control_base
    gui_hint: 0,0,1,2
    label: Debug Mode
    label0: DISABLED (ADC)
    label1: CONT_NBITS (Counter)
    label2: MIDSCALE_SH
    label3: DESERIALIZER
    num_opts: '4'
    option0: '0'
    option1: '15'
    option2: '1'
    option3: '13'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: fifo_input_mux
  id: variable_qtgui_chooser
  parameters:
    comment: FIFO_Input_Mux_Control
    gui_hint: 2,0,1,2
    label: FIFO Input
    label0: NONE
    label1: PREPROC_DATA
    label2: COUNTER_POST_PROC
    label3: RAW_DATA
    label4: MUX_DATA
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65000000'
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    label: RESET System
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_push_button_1
  id: variable_qtgui_push_button
  parameters:
    label: ENABLE Acquisition
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f:\Proyectos\sist_adq_dbf\gnuradio\sink_UDP
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f:\Proyectos\sist_adq_dbf\gnuradio\sink_channel0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_10
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_6
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_7
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_8
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_9
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import sys
      sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf')
      sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf\gnuradio')

      import numpy as np
      from gnuradio import gr
      import ciaa_control

      class blk(gr.sync_block):
          """Maneja clicks de botones CIAA"""
          def __init__(self, reset_btn=0, enable_btn=0):
              gr.sync_block.__init__(
                  self,
                  name='CIAA Button Handler',
                  in_sig=None,
                  out_sig=None
              )
              self.ctrl = ciaa_control.get_controller()
              self.reset_btn = reset_btn
              self.enable_btn = enable_btn
              self.last_reset = 0
              self.last_enable = 0
          
          def set_reset(self, val):
              """Callback para botón RESET"""
              if val == 1 and self.last_reset == 0:  # Flanco ascendente
                  print("\n🔄 RESET System pressed")
                  if self.ctrl:
                      self.ctrl.reset_system()
                      self.ctrl.reset_fifo()
              self.last_reset = val
          
          def set_enable(self, val):
              """Callback para botón ENABLE"""
              if val == 1 and self.last_enable == 0:  # Flanco ascendente
                  print("\n▶ ENABLE Acquisition pressed")
                  if self.ctrl:
                      self.ctrl.enable_system(True)
              self.last_enable = val
          
          def work(self, input_items, output_items):
              # Monitorear cambios en botones
              if hasattr(self, 'reset_btn') and self.reset_btn != self.last_reset:
                  self.set_reset(self.reset_btn)
              
              if hasattr(self, 'enable_btn') and self.enable_btn != self.last_enable:
                  self.set_enable(self.enable_btn)
              
              return 0
    enable_btn: variable_qtgui_push_button_1
    reset_btn: variable_qtgui_push_button_0
  states: {}
- name: epy_block_ciaa_apply
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import sys
      sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf')
      sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf\gnuradio')
      import ciaa_control

      class blk(gr.basic_block):
          """Aplica configuración CIAA"""
          def __init__(self, debug_mode=0, data_source=0, fifo_input=0):
              gr.basic_block.__init__(
                  self,
                  name='CIAA Config Apply',
                  in_sig=None,
                  out_sig=None
              )
              self.ctrl = ciaa_control.get_controller()
              self.last_debug = -1
              self.last_source = -1
              self.last_fifo = -1
              print("OK CIAA Config Apply inicializado")
          
          def set_debug_mode(self, val):
              if self.ctrl and self.last_debug != val:
                  self.ctrl.set_debug_mode(val)
                  self.last_debug = val
          
          def set_data_source(self, val):
              if self.ctrl and self.last_source != val:
                  self.ctrl.set_data_source_mux(val)
                  self.last_source = val
          
          def set_fifo_input(self, val):
              if self.ctrl and self.last_fifo != val:
                  self.ctrl.set_fifo_input_mux(val)
                  self.last_fifo = val
    comment: Bloque que aplica configuración SSH
    data_source: data_source_mux
    debug_mode: debug_mode
    fifo_input: fifo_input_mux
  states: {}
- name: epy_block_unpacker
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import struct
      import numpy as np

      NUM_CHANNELS = 16
      SAMPLES_PER_PACKET = 21
      PACKET_HEADER_SIZE = 88
      EXPECTED_PACKET_SIZE = 1432
      MAX_PACKETS_PER_WORK = 10

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='CIAA UDP Unpacker',
                  in_sig=[np.uint8],
                  out_sig=[np.float32]*NUM_CHANNELS
              )
              self.buffer = bytearray()
              self.packet_count = 0
              self.error_count = 0
              self.set_output_multiple(SAMPLES_PER_PACKET)
          
          def work(self, input_items, output_items):
              in_len = len(input_items[0])
              self.buffer.extend(input_items[0].tobytes())
              
              n_produced = 0
              max_output = len(output_items[0])
              packets_processed = 0

              while (len(self.buffer) >= EXPECTED_PACKET_SIZE and 
                     n_produced + SAMPLES_PER_PACKET <= max_output and
                     packets_processed < MAX_PACKETS_PER_WORK):
                  
                  data = self.buffer[:EXPECTED_PACKET_SIZE]
                  self.buffer = self.buffer[EXPECTED_PACKET_SIZE:]
                  self.packet_count += 1
                  packets_processed += 1

                  try:
                      payload_start = PACKET_HEADER_SIZE
                      
                      for row in range(SAMPLES_PER_PACKET):
                          for ch in range(NUM_CHANNELS):
                              offset = payload_start + (row * NUM_CHANNELS * 4) + (ch * 4)
                              
                              if offset + 4 <= len(data):
                                  word32 = struct.unpack('<I', data[offset:offset+4])[0]
                                  value16 = word32 & 0xFFFF
                                  signed_val = struct.unpack('<h', struct.pack('<H', value16))[0]
                                  output_items[ch][n_produced] = float(signed_val)
                          
                          n_produced += 1
                      
                  except Exception as e:
                      self.error_count += 1
                      if self.error_count <= 10:
                          print(f"ERROR paquete #{self.packet_count}: {e}")

              if self.packet_count % 100 == 0 and self.packet_count > 0:
                  print(f"Paquete {self.packet_count}: {packets_processed} procesados, buffer: {len(self.buffer)} bytes")

              self.consume_each(in_len)
              return n_produced
          
          def stop(self):
              print(f"\n=== ESTADÍSTICAS FINALES ===")
              print(f"Paquetes procesados: {self.packet_count}")
              print(f"Errores: {self.error_count}")
              print(f"Tasa error: {100*self.error_count/max(1, self.packet_count):.2f}%")
              return True
  states: {}
- name: import_ciaa
  id: import
  parameters:
    imports: import sys; sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf\gnuradio'); sys.path.insert(0, r'f:\Proyectos\sist_adq_dbf'); import ciaa_control
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '9999'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '512'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 8,0,4,4
    label1: Ch0
    label2: Ch1
    label3: Ch2
    label4: Ch3
    name: '"CIAA Spectrum"'
    nconnections: '4'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 4,0,4,4
    label1: Ch0
    label2: Ch1
    label3: Ch2
    label4: Ch3
    name: '"CIAA Channels 0-3"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '20000'
    ymin: '-20000'
  states: {}

connections:
- [epy_block_unpacker, '0', blocks_file_sink_1, '0']
- [epy_block_unpacker, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_unpacker, '0', qtgui_time_sink_x_0, '0']
- [epy_block_unpacker, '1', qtgui_freq_sink_x_0, '1']
- [epy_block_unpacker, '1', qtgui_time_sink_x_0, '1']
- [epy_block_unpacker, '10', blocks_null_sink_0_0, '0']
- [epy_block_unpacker, '11', blocks_null_sink_0_1, '0']
- [epy_block_unpacker, '12', blocks_null_sink_0_2, '0']
- [epy_block_unpacker, '13', blocks_null_sink_0_9, '0']
- [epy_block_unpacker, '14', blocks_null_sink_0_7, '0']
- [epy_block_unpacker, '15', blocks_null_sink_0_3, '0']
- [epy_block_unpacker, '2', qtgui_freq_sink_x_0, '2']
- [epy_block_unpacker, '2', qtgui_time_sink_x_0, '2']
- [epy_block_unpacker, '3', qtgui_freq_sink_x_0, '3']
- [epy_block_unpacker, '3', qtgui_time_sink_x_0, '3']
- [epy_block_unpacker, '4', blocks_null_sink_0_8, '0']
- [epy_block_unpacker, '5', blocks_null_sink_0, '0']
- [epy_block_unpacker, '6', blocks_null_sink_0_10, '0']
- [epy_block_unpacker, '7', blocks_null_sink_0_6, '0']
- [epy_block_unpacker, '8', blocks_null_sink_0_5, '0']
- [epy_block_unpacker, '9', blocks_null_sink_0_4, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_stream_x_0, '0', epy_block_unpacker, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
